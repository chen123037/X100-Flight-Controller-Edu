# Repository chen123037/X100-Flight-Controller-Edu (continued)

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb (continued)

Parts:
J701, J702, J703: SM06B-GHS-TB(LF)(SN); Official_Connector_JST_JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm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; MPN SM06B-GHS-TB(LF)(SN)
J704: SM04B-GHS-TB(LF)(SN); Official_Connector_JST_JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm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; MPN SM04B-GHS-TB(LF)(SN)
R701: 4.7k externalSCL pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-074K7L
R702: 4.7k externalSDA pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-074K7L

Connections:
3V3_MCU: R701.1, R702.1; also elsewhere on the board
EXT_5V: J701.1, J702.1, J703.1, J704.1; also elsewhere on the board
EXT_I2C1_SCL: J701.4, J704.2, R701.2; also elsewhere on the board
EXT_I2C1_SDA: J701.5, J704.3, R702.2; also elsewhere on the board
GND: J701.6, J702.6, J703.6, J704.4; also elsewhere on the board
GPS_RX: J701.3; also elsewhere on the board
GPS_TX: J701.2; also elsewhere on the board
RC_RX: J703.3; also elsewhere on the board
RC_TX: J703.2; also elsewhere on the board
TELEM_RX: J702.3; also elsewhere on the board
TELEM_TX: J702.2; also elsewhere on the board

Notes on the sheet:
External5V is protected EXT_5V; all UART/I2C signals3.3V.
GPS: FC_TX to receiverRX
TELEM:4/5 NC no flow control
RC: CRSF3.3V logic;4/5 NC
GPS and externalI2C share I2C1. Combined pullups/cable capacitance must satisfy rise time.
07 串口与通用IO / UART AND GENERAL I/O
GPS 接口 / GPS INTERFACE
遥测接口 / TELEMETRY INTERFACE
RC 接收机 / RC RECEIVER · CRSF
外部 I2C / EXTERNAL I2C
GPS / TELEM
RC / EXTERNAL I2C
POWER / GND

Schematic: 08_PWM_ADC_DEBUG.kicad_sch

Parts:
C801: 100n ADC LPF; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0805C104K5RACTU
C802: 100n X7R 50V; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0805C104K5RACTU
C803, C804: 22n X7R 50V ADC reservoir; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0805C223K5RACTU
C805: 100n U801 VDD14; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
J801: OUT1 /GND; Samtec_TSW10207GS_1x2_P2p54; MPN TSW-102-07-G-S
J802: OUT2 /GND; Samtec_TSW10207GS_1x2_P2p54; MPN TSW-102-07-G-S
J803: OUT3 /GND; Samtec_TSW10207GS_1x2_P2p54; MPN TSW-102-07-G-S
J804: OUT4 /GND; Samtec_TSW10207GS_1x2_P2p54; MPN TSW-102-07-G-S
J805: OUT5 /GND; Samtec_TSW10207GS_1x2_P2p54; MPN TSW-102-07-G-S
J806: OUT6 /GND; Samtec_TSW10207GS_1x2_P2p54; MPN TSW-102-07-G-S
J807: SWD:1REF2GND3IO4CLK5NRST; Samtec_TSW10507GS_1x5_P2p54; MPN TSW-105-07-G-S
J808: BATTERY/bench3S-6S ONLY; VBAT_PAD_PAIR_V1; MPN VBAT_PAD_PAIR_V1
J809: CURRENT monitor only; Official_Connector_JST_JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm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; MPN SM06B-GHS-TB(LF)(SN)
R801: 150k 0.1%; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 0.1%; TCR<=25ppm/C; Voltage Rating >=100V; MPN RT0805BRD07150KL
R802: 10k 0.1% scale16; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 0.1%; TCR<=25ppm/C; Voltage Rating >=100V; MPN RT0805BRD0710KL
R803: 1k ADC series; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-071KL
R804, R808: 1k isolate ADC reservoir; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-071KL
R805: 22.1k 1% >=100V; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0722K1L
R806: 20k 1% scale20/42.1; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0720KL
R807: 1k current limit; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-071KL
R809, R810: 1.3M 1% discharge/IOFF bound; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-071M3L
R811: 10k rail discharge; off bound 81.6mV; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
TP803: VBAT_ADC; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP805: CURRENT_ADC; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
U801: TMUX1511PWR; Official_Package_SO_TSSOP-14_4.4x5mm_P0.65mm; MPN TMUX1511PWR

Connections:
3V3_MCU: C805.1, J807.1, R811.1, U801.1 (SEL1), U801.4 (SEL2), U801.14 (VDD); also elsewhere on the board
CURRENT_ADC: C804.1, R808.2, R810.1, TP805.1; also elsewhere on the board
CURRENT_ADC_ISOLATED: R808.1, U801.6 (D2)
CURRENT_ADC_PRE_PROTECTION: C802.1, R807.2, U801.5 (S2)
CURRENT_DIV: R805.2, R806.1, R807.1
CURRENT_IN_RAW: J809.3, R805.1
GND: C801.2, C802.2, C803.2, C804.2, C805.2, J801.2, J802.2, J803.2, J804.2, J805.2, J806.2, J807.2, J808.2 (GND-), J809.5, J809.6, R802.2, R806.2, R809.2, R810.2, R811.2, U801.7 (GND), U801.8 (D3), U801.9 (S3), U801.10 (SEL3), U801.11 (D4), U801.12 (S4), U801.13 (SEL4); also elsewhere on the board
NRST: J807.5; also elsewhere on the board
OUT1: J801.1; also elsewhere on the board
OUT2: J802.1; also elsewhere on the board
OUT3: J803.1; also elsewhere on the board
OUT4: J804.1; also elsewhere on the board
OUT5: J805.1; also elsewhere on the board
OUT6: J806.1; also elsewhere on the board
SWCLK: J807.4; also elsewhere on the board
SWDIO: J807.3; also elsewhere on the board
VBAT_ADC: C803.1, R804.2, R809.1, TP803.1; also elsewhere on the board
VBAT_ADC_ISOLATED: R804.1, U801.3 (D1)
VBAT_ADC_PRE_PROTECTION: C801.1, R803.2, U801.2 (S1)
VBAT_DIV: R801.2, R802.1, R803.1
VBAT_PROTECTED: R801.1; also elsewhere on the board
VBAT_RAW: J808.1 (VBAT_RAW+); also elsewhere on the board

Notes on the sheet:
PWM signal+GND only. Custom SWD5pin. Pack current NEVER passes through board.
CURRENT:0..5V normal,0..6V bounded DC fault, shared GND; no VBAT/negative-fault rating.
PC0/PC1 are FT_a. No rail-clamp diode added: external U801 powered-off isolation + bleed.
150k/10k remains nominal1/16; finite1.3M loading gives actual scale16.1401. Calibrate.
08 PWM / ADC / 调试 · PWM / ADC / DEBUG
六路 PWM 输出 / SIX PWM OUTPUTS
SWD 调试与电池输入 / SWD AND BATTERY INPUT
电压采样 / VOLTAGE SENSE · ADC PC0
电流输入采样 / CURRENT INPUT · ADC PC1
掉电隔离与保持 / POWERED-OFF ISOLATION
ADC 输出滤波 / ADC OUTPUT FILTERS
PWM / ADC
DEBUG / POWER

Schematic: 09_USB_CORE_POWER.kicad_sch

Parts:
C121: 180u /16V core mux hold-up (+ pin1); Panasonic_OSCON_C6; MPN 16SVPF180M
C123: 1u /16V shared input bypass; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C105K4RACTU
C124: 1u /16V; Official_Capacitor_SMD_C_0805_2012Metric; MPN C0805C105K4RACTU
C125: 1u /16V mux VIN1; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C105K4RACTU
R111: 33.2k 0.1%; Official_Resistor_SMD_R_0805_2012Metric; MPN RT0805BRD0733K2L
R112: 10k 0.1%; Official_Resistor_SMD_R_0805_2012Metric; MPN RT0805BRD0710KL
R113: 49.9k 0.1%; Official_Resistor_SMD_R_0805_2012Metric; MPN RT0805BRD0749K9L
R114: 10k ST pull-up; Official_Resistor_SMD_R_0805_2012Metric; MPN RC0805FR-0710KL
U105: TPS2116DRLR; SOT-583-8; MPN TPS2116DRLR
U106: TPS2553DBVR; Official_Package_TO_SOT_SMD_SOT-23-6; MPN TPS2553DBVR

Connections:
3V3_MCU: R114.1; also elsewhere on the board
5V_CORE: C121.1, U105.2 (VOUT), U105.7 (VOUT); also elsewhere on the board
5V_MAIN: C125.1, R111.1, U105.3 (VIN1), U105.5 (MODE); also elsewhere on the board
CORE_BAT_SELECTED: R114.2, U105.8 (ST); also elsewhere on the board
CORE_PWR_PRIORITY: R111.2, R112.1, U105.4 (PR1)
GND: C121.2, C123.2, C124.2, C125.2, R112.2, R113.2, U105.1 (GND), U106.2 (GND); also elsewhere on the board
USB_5V_LIMITED: C124.1, U105.6 (VIN2), U106.6 (OUT)
USB_PWR_ILIM: R113.1, U106.5 (ILIM)
USB_VBUS_RAW: C123.1, U106.1 (IN), U106.3 (EN); also elsewhere on the board

Notes on the sheet:
B143: single USB current limit; MCU, sensors, SD and CAN powered from core. External 5V is battery-only.

Schematic: 10_USB_STARTUP_GUARD.kicad_sch

Parts:
C126: 1u /16V mux output; Official_Capacitor_SMD_C_0805_2012Metric; MPN C0805C105K4RACTU

Connections:
5V_CORE: C126.1; also elsewhere on the board
GND: C126.2; also elsewhere on the board

Notes on the sheet:
B143: single USB current limit; MCU, sensors, SD and CAN powered from core. External 5V is battery-only.

Board: 6 copper layers, 70.0 x 52.0 mm, 174 parts (103 on the bottom side), 89 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_4mm
