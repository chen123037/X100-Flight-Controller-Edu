# Repository chen123037/X100-Flight-Controller-Edu

File README.md:

# X100 飞控硬件平台

基于STM32H743、BMI088、SPL06-001，面向ArduPilot适配与教学的六层飞控项目。

> **当前PCB下单资料入口：[六层V4，DFM零危险版本](hardware/current/X100_6L_DFM_ZERO_DANGER/)。**
> 可用于上传嘉立创创建订单及工程审稿；U101/D103整板热审查和实际工厂工艺接受尚未闭合，未宣告整板制造放行或飞行验收。

## 直接下载

- [完整当前工程、制造资料与购买清单](hardware/current/X100_6L_DFM_ZERO_DANGER/download/X100_六层当前版_工程制造及清单.zip)
- [当前Gerber/钻孔ZIP](hardware/current/X100_6L_DFM_ZERO_DANGER/manufacturing/X100_6L_DFM_gap_silk_v4.zip)
- [嘉立创参数与U101树脂塞孔盖帽说明](hardware/current/X100_6L_DFM_ZERO_DANGER/manufacturing/嘉立创下单参数与六孔说明.md)
- [实际货源核查：商品直达页、库存、MOQ、交期及候选](hardware/current/X100_6L_DFM_ZERO_DANGER/procurement/actual_sourcing/)
- [淘宝器件清单：62种MPN、每板142件](hardware/current/X100_6L_DFM_ZERO_DANGER/procurement/)
- [KiCad当前工程](hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pro)
- [原生DFM报告](hardware/current/X100_6L_DFM_ZERO_DANGER/evidence/JLC_DFM_NATIVE_REPORT_0_DANGER.pdf)

## 当前事实

| 项目 | 当前六层版 |
|---|---|
| 结构 | 六层、1.6mm、JLC06161H-3313、约70×52mm外廓及四个安装耳 |
| 安装孔 | 四个Ø4 NPTH、孔距60×42mm、双面Ø7接触包络 |
| 数量 | 174个总封装；144功能位号、26TP、4孔；采购142实例/62种MPN |
| 连接与检查 | ERC0；DRC电气错误0、未连接0、parity0；另56条库副本差异警告 |
| PCB DFM | 实际嘉立创任务所报危险0、黄色468；黄色项目仍在报告中 |
| 工艺条件 | 沉金、绿油白字、高精字符；U101六孔树脂填孔并电镀盖帽，实际范围/生产稿待工厂确认 |
| 当前未放行项 | U101/D103整板热设计风险接受；实板电流/温升、固件、无桨及飞行验证未执行 |

PCB SHA256：`09537241b43be8cdf2aa150a8214c6ce9225da4f3d8592bd108919dc2d73b529`。

本次实际DFM制造ZIP SHA256：`85254aca1ba4356953ddff8653cff87964dce0b77bb30dd6c1584126908b1bfc`。详细资料身份见[当前目录](hardware/current/X100_6L_DFM_ZERO_DANGER/)和[状态](STATUS.md)。

## 后续工作与历史

[接手说明](HANDOFF.md) · [剩余路线图](docs/ROADMAP.md) · [采购指南](docs/PROCUREMENT_GUIDE.md) · [首板计划](docs/BRINGUP_PLAN.md)。旧功能/电源背景文档可能对应早期基线；当前器件、层数、孔位、TP及网络以当前六层工程为准。

`hardware/reviews/X100_C8_LAYOUT_REVIEW/`保留c8四层、96项未连接的历史评审包；`hardware/X100_V1/`保留旧45×45源。本次没有覆盖它们。旧首页与状态快照见[历史目录](docs/history/pre_6L_DFM/)。当前工作在`feature/pcb-fabrication-readiness`，不自动合并main。

原创硬件采用CERN-OHL-P-2.0，原创文档采用CC BY 4.0，KiCad派生部分保留原许可。见[LICENSE](LICENSE)、[许可决定](LICENSE_DECISION.md)及[第三方说明](docs/THIRD_PARTY_NOTICES.md)。开放许可与设计验证状态分别记录。

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb

File hardware/current/X100_6L_DFM_ZERO_DANGER/README.md:

# X100 当前六层工程与 PCB 下单资料

**这是当前用于上传嘉立创创建PCB订单、提交工程审稿的资料版本：六层V4，PCB DFM所报危险0。** 当前制造ZIP与本次实际DFM上传文件逐字节一致。它不是旧c8，也不是旧45×45工程。

**当前没有宣告整板制造放行或飞行验收。** U101/D103整板热审查仍未签署通过，工厂实际叠层/填孔范围和生产稿也需确认；请保留这些真实边界，不把0危险写成全项PASS。

## 下载与打开

- [完整工程、制造文件、检查证据和购买清单ZIP](download/X100_六层当前版_工程制造及清单.zip)
- [仅Gerber/钻孔：本次实际DFM零危险ZIP](manufacturing/X100_6L_DFM_gap_silk_v4.zip)
- [KiCad10工程](project/X100_CleanSheet.kicad_pro)；11张原理图、自定义符号/封装库随附，保持相对库表。
- [嘉立创下单参数与六孔说明](manufacturing/嘉立创下单参数与六孔说明.md) · [六孔定位图](images/U101六孔_板厂定位图.png)
- [实际货源核查：62项真实商品链接、MOQ与交期](procurement/actual_sourcing/)
- [淘宝器件清单与完整MPN](procurement/) · [可筛选Excel](procurement/X100_当前淘宝器件清单.xlsx)
- [嘉立创原生PDF报告](evidence/JLC_DFM_NATIVE_REPORT_0_DANGER.pdf) · [全部原生计数](evidence/JLC_DFM_NATIVE_ALL_COUNTS.json)

使用KiCad10.0.6或兼容KiCad10，并安装官方标准库和3D模型。3D模型使用KICAD10_3DMODEL_DIR；原理图自定义库和PCB封装在project内。部分CAD标题栏/旧text_variables仍有历史HOLD或USB_MODE文字，发布过程没有为了改标题栏而重写源CAD；当前状态以本文和实际网表/检查为准。

## 当前核验事实

| 项目 | 结果 |
|---|---|
| 叠层与板形 | 6层、名义1.6mm、JLC06161H-3313；外廓约70×52mm，四个Ø4 NPTH，孔距60×42mm |
| 器件与测试点 | 174个PCB封装：144个功能位号、26个TP、4个孔；其中142个实例需采购，62种MPN |
| 布线/一致性 | 0未连接、0原理图一致性差异；2071条线段、332过孔、5块铜区 |
| ERC/DRC | fresh ERC0；DRC0错误，另56条库副本差异警告，未隐藏 |
| 原生PCB DFM | 35个结果行所报危险0、黄色468；计数沿用软件显示口径，不视为物理对象总数 |
| 未完成的接受 | 整板热设计、实际工厂工艺/生产稿确认；首板启动/温升/固件/无桨/飞行测试未执行 |

PCB SHA256：`09537241b43be8cdf2aa150a8214c6ce9225da4f3d8592bd108919dc2d73b529`。

实际DFM制造ZIP SHA256：`85254aca1ba4356953ddff8653cff87964dce0b77bb30dd6c1584126908b1bfc`。任务`DFMP2610310277`；包含6铜层、2阻焊、2丝印、板框、Gerber job及PTH/NPTH钻孔共14文件。

## 选工艺时必须明确

六层、1.6mm、外铜1oz/内铜0.5oz、沉金、绿油白字、高精字符，使用上述指定叠层。U101.9六孔必须树脂塞孔＋电镀盖帽填平，不能用普通盖油/塞油代替。原有USB两颗0.50/0.20mm过孔保持；其它新增孔采用0.60/0.30mm。

当前官方六层默认树脂塞孔盖帽的范围由工厂审稿列明，不能把连接器插孔、J401固定槽或安装孔塞住。J401原厂0.45mm有铜槽保持，不因通用DFM阈值加大；仅此槽宽阈值已按人工批准使用多层板0.35mm，其余规则保持。

原生PDF导出存在页面工艺表头回到默认喷锡的现象，PDF原样保留。**实际选择为沉金ENIG**，以Gerber job和[沉金页面截图](images/JLC_DFM_六层沉金_概述.jpg)核对，不能按PDF表头改喷锡。

## 本次发布范围

61项源CAD/库表逐字节复制，没有重新编辑PCB或原理图。最后局部修改只包括已批准的R113避让、重复红项相关过孔/支线和少量文字；具体读回证据在evidence。公开证据仅去除本机路径，原生制造ZIP、原生DFM PDF及源CAD不改字节。旧c8/旧正式源保留；本工作分支不自动合并main。

当前原生CPL仅供装联审查，尚未做贴片方吸附原点、底面角度、料号及面别验收；不能混用旧CPL。器件搜索清单也不是已验真淘宝商品或采购批准。

许可：原创硬件与文档沿用仓库许可；KiCad派生库保留原许可和例外。见[第三方说明](licenses/THIRD_PARTY_NOTICES.md)及下载包内licenses。

Notes on the sheet:
X100 CLEAN-SHEET | PHYSICAL SCHEMATIC
VBAT 3S-6S -> 5V_MAIN -> 3V3_MCU / 3V3_SENSOR / protected EXT_5V
USB: DATA ONLY + VBUS SENSE. USB_VBUS never joins 5V_MAIN.
Physical pins are wired in subsheets. Only nonblocking board/test qualifications are listed in GATE1 exports.
PHYSICAL SUBSHEET PIN-NET TABLE EXPORTED

Parts:
C101, C102, C103, C104: 10u /50V X7R; Official_Capacitor_SMD_C_1210_3225Metric; Tolerance 10%; Voltage Rating >=50V; MPN C1210C106K5RACTU
C105: 39u /50V +VIN; Panasonic_OSCON_E12; MPN 50SVPF39M
C106: 100n /50V 0603 VIN loop; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C107: 100n BOOT-SW; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C108: 180u /16V +5V_MAIN; Panasonic_OSCON_C6; MPN 16SVPF180M
C109: 22n COMP series; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0805C223K5RACTU
C110: 240p COMP pole; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 5%; Voltage Rating >=50V; MPN C0805C241J5GACTU
C111: 10u AP input; Official_Capacitor_SMD_C_1210_3225Metric; Tolerance 10%; Voltage Rating >=50V; MPN C1210C106K5RACTU
C112: 100n BST-SW; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C113, C114: 22u /16V; Official_Capacitor_SMD_C_1210_3225Metric; Tolerance 10%; Voltage Rating >=16V; MPN C1210C226K4RACTU
C115: 2.2u /16V input; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C225K4RACTU
C116: 2.2u /16V output; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C225K4RACTU
C117: 100n switch input loop; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C118: 10u switch input; Official_Capacitor_SMD_C_1210_3225Metric; Tolerance 10%; Voltage Rating >=50V; MPN C1210C106K5RACTU
C119: 82u /16V PTC-before bulk; Panasonic_OSCON_B6; MPN 16SVPF82M
C120: 1u EXT local; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C105K4RACTU
D101: 12V VGS clamp K=source; Official_Diode_SMD_D_SOD-123F; MPN BZT52H-C12,115
D102: 26V bidirectional TVS; Official_Diode_SMD_D_SMB; MPN SMBJ26CA-TR
D103: STPS8H100G-TR; STPS8H100G_D2PAK_A_K_TabK_NoVIP; MPN STPS8H100G-TR
F101: 3A /125V; Official_Fuse_Fuse_Littelfuse-NANO2-451_453; MPN 0451003.MRL
L101: 10uH; Bourns_SRP1038A_LeadFrame_NoVIP; MPN SRP1038A-100M; LCSC C780184
L102: 4.7uH design-calculated at 5V; Bourns_SRN6045; MPN SRN6045-4R7Y
Q101: DMP6023LSS-13; Official_Package_SO_SOIC-8_3.9x4.9mm_P1.27mm; MPN DMP6023LSS-13
R101: 20k; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0720KL
R102: 294k; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-07294KL
R103: 54.9k; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0754K9L
R104: 200k; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-07200KL
R105: 53.6k 0.1%; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 0.1%; TCR<=25ppm/C; Voltage Rating >=100V; MPN RT0805BRD0753K6L
R106: 10k 0.1%; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 0.1%; TCR<=25ppm/C; Voltage Rating >=100V; MPN RT0805BRD0710KL
R107: 18.7k; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0718K7L
R108: 10R RC sensor filter; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710RL
R109: 22.1k limit; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0722K1L
R110: 10k FAULT pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
TP101: VBAT_RAW; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP103: VBAT_PROTECTED; TP1p5_NoPaste; MPN TP1p5
TP104: 5V_MAIN; TP1p5_NoPaste; MPN TP1p5
TP105: 3V3_MCU; TP1p5_NoPaste; MPN TP1p5
TP106: SENSOR_LDO_IN; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP107: 3V3_SENSOR; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP109: EXT_5V; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP110: EXT_FAULT; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP111: GND; TP1p5_NoPaste; MPN TP1p5
U101: TPS54360BDDAR; TPS54360B_DDA0008B_NoVIP; MPN TPS54360BDDAR
U102: AP63203WU-7; Official_Package_TO_SOT_SMD_TSOT-23-6; MPN AP63203WU-7
U103: TPS7A2033PDBVR; Official_Package_TO_SOT_SMD_SOT-23-5; MPN TPS7A2033PDBVR
U104: TPS2553DBVR; Official_Package_TO_SOT_SMD_SOT-23-6; MPN TPS2553DBVR

Connections:
3V3_MCU: C113.1, C114.1, L102.2, R110.1, TP105.1 (TP_1), U102.1 (FB), U103.3 (EN); also elsewhere on the board
3V3_SENSOR: C116.1, TP107.1, U103.5 (OUT); also elsewhere on the board
5V_CORE: C111.1, R108.1, U102.2 (EN), U102.3 (IN); also elsewhere on the board
5V_MAIN: C108.1, C117.1, C118.1, L101.2, R105.1, TP104.1 (TP_1), U104.1 (IN), U104.3 (EN); also elsewhere on the board
EXT_5V: C119.1, C120.1, TP109.1, U104.6 (OUT); also elsewhere on the board
EXT_FAULT: R110.2, TP110.1, U104.4 (~FAULT)
EXT_ILIM: R109.1, U104.5 (ILIM)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C108.2, C109.2, C110.2, C111.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, D102.2 (A2), D103.A, R101.2, R103.2, R104.2, R106.2, R109.2, TP111.1 (TP_1), U101.7 (GND), U101.9 (GNDPAD), U102.4 (GND), U103.2 (GND), U104.2 (GND); also elsewhere on the board
MAIN_BOOT: C107.1, U101.1 (BOOT)
MAIN_COMP: C110.1, R107.1, U101.6 (COMP)
MAIN_COMP_RC: C109.1, R107.2
MAIN_EN: R102.2, R103.1, U101.3 (EN)
MAIN_FB: R105.2, R106.1, U101.5 (FB)
MAIN_RT: R104.1, U101.4 (RT/CLK)
MAIN_SW: C107.2, D103.K (K_TAB), L101.1, U101.8 (SW)
MCU_BOOT: C112.1, U102.6 (BST)
MCU_SW: C112.2, L102.1, U102.5 (SW)
RP_GATE: D101.2 (A), Q101.4 (G), R101.1
SENSOR_LDO_IN: C115.1, R108.2, TP106.1, U103.1 (IN)
VBAT_FUSED: F101.2, Q101.5 (D), Q101.6 (D), Q101.7 (D), Q101.8 (D)
VBAT_PROTECTED: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, D101.1 (K), D102.1 (A1), Q101.1 (S), Q101.2 (S), Q101.3 (S), R102.1, TP103.1 (TP_1), U101.2 (VIN); also elsewhere on the board
VBAT_RAW: F101.1, TP101.1; also elsewhere on the board

Notes on the sheet:
MAIN 5V: battery/bench only, 3S-6S. USB is never a supply.
TPS2553 constant-current limiting; recovers after overload removal, subject to thermal protection.
01 电源管理 / POWER MANAGEMENT
VBAT 输入与保护 / VBAT INPUT AND PROTECTION
VBAT_RAW → VBAT_FUSED → VBAT_PROTECTED
主 5V 降压电源 / MAIN 5V BUCK
BOOT / SW / EN / RT / FB / COMP — 原网络保持
MCU 3.3V 电源 / MCU 3V3 SUPPLY
传感器 3.3V 电源 / SENSOR 3V3
受控外部 5V / CONTROLLED EXTERNAL 5V
VBAT / MAIN 5V
MCU / SENSOR POWER
EXTERNAL 5V / GND
