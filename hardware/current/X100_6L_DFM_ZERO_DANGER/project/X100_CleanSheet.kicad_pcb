# Repository chen123037/X100-Flight-Controller-Edu (continued)

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb (continued)

Parts:
C501: 100n socket VDD loop; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C502: 10u /50V SD local; Official_Capacitor_SMD_C_1210_3225Metric; Tolerance 10%; Voltage Rating >=50V; MPN C1210C106K5RACTU
J501: 1040310811; Official_Connector_Card_microSD_HC_Molex_104031-0811; MPN 1040310811
R501: 0R SD service isolation; Official_Resistor_SMD_R_0805_2012Metric; Tolerance jumper; Voltage Rating >=100V; MPN RC0805JR-070RL
R502, R503, R504, R505, R506: 47k SD pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0747KL
TP501: 3V3_SD; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE

Connections:
3V3_MCU: R501.1; also elsewhere on the board
3V3_SD: C501.1, C502.1, J501.4 (VDD), R501.2, R502.1, R503.1, R504.1, R505.1, R506.1, TP501.1
GND: C501.2, C502.2, J501.6 (VSS), J501.SH (SHIELD); also elsewhere on the board
SDMMC1_CK: J501.5 (CLK); also elsewhere on the board
SDMMC1_CMD: J501.3 (CMD), R502.2; also elsewhere on the board
SDMMC1_D0: J501.7 (DAT0), R503.2; also elsewhere on the board
SDMMC1_D1: J501.8 (DAT1), R504.2; also elsewhere on the board
SDMMC1_D2: J501.1 (DAT2), R505.2; also elsewhere on the board
SDMMC1_D3: J501.2 (DAT3/CD), R506.2; also elsewhere on the board

Notes on the sheet:
SDMMC1 4-bit, 3.3V only. Contact9/10 detect NC; no detect GPIO.
No arbitrary damping resistor or 1.8V UHS. Series damping only after signal-integrity evidence.
05 microSD数据存储 / MICROSD STORAGE
microSD 接口与信号上拉 / MICROSD AND SDMMC PULLUPS
本地供电与去耦 / LOCAL POWER AND DECOUPLING
STM32 SDMMC1 ↔ microSD · 3.3V / 4-bit
SDMMC / SIGNALS
POWER / GND
