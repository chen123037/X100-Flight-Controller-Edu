# Repository chen123037/X100-Flight-Controller-Edu (continued)

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb (continued)

Parts:
C601: 100n VCC3 loop; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
J601: SM04B-GHS-TB(LF)(SN); Official_Connector_JST_JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm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; MPN SM04B-GHS-TB(LF)(SN)
JP601: CAN TERM 120R / OPEN; CAN_SolderJumper_2_Open_Pad1p0x1p5_NoPaste
R602: 120R end termination; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-07120RL
R603: 10k TXD default recessive; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
R604: 10k; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
U601: TCAN3414DR; TCAN3414_D0008A_SOIC8; MPN TCAN3414DR

Connections:
3V3_MCU: C601.1, R603.1, R604.1, U601.3 (VCC); also elsewhere on the board
CANH: J601.2, R602.1, U601.7 (CANH)
CANL: J601.3, JP601.2 (B), U601.6 (CANL)
CAN_RX: U601.4 (RXD); also elsewhere on the board
CAN_STB: R604.2, U601.8 (STB); also elsewhere on the board
CAN_TERM: JP601.1 (A), R602.2
CAN_TX: R603.2, U601.1 (TXD); also elsewhere on the board
EXT_5V: J601.1; also elsewhere on the board
GND: C601.2, J601.4, U601.2 (GND), U601.5 (SHDN); also elsewhere on the board

Notes on the sheet:
TCAN3414DR 3.3V; Classical CAN only. SHDN=0,STB=0: Normal mode.
JP601 CAN TERM / 120R: manufacture OPEN (disabled). Manually solder bridge only at bus end (enabled). NO PASTE; wick clean to restore OPEN.
Built-in bus standoff +/-58V; receiver common mode +/-30V; bus-pin IEC ESD +/-10kV.
EXTERNAL_CAN_TVS=NOT_REQUIRED_FOR_V1. Whole-board IEC qualification deferred to test.
06 CAN通信 / CAN INTERFACE
CAN 收发器 / CAN TRANSCEIVER
CAN 总线接口 / CAN BUS CONNECTOR
120Ω 终端 / CAN TERMINATION · 默认OPEN
CANH → R602 → CAN_TERM → JP601 → CANL
接口与测点 / INTERFACES AND TEST POINTS
MCU / CONTROL
CANH / CANL / POWER
