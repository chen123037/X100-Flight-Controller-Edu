# Repository chen123037/X100-Flight-Controller-Edu (continued)

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb (continued)

Parts:
C201, C202: 2.2u VCAP /16V; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C225K4RACTU
C203: 100n local VDD pin11; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C204: 100n local VDD pin27; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C205: 100n local VDD pin50; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C206: 100n local VDD pin75; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C207: 100n local VDD pin100; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C208: 10u /50V MCU bulk >=4.7u effective; Official_Capacitor_SMD_C_1210_3225Metric; Tolerance 10%; Voltage Rating >=50V; MPN C1210C106K5RACTU
C209: 2.2u VDDA; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=16V; MPN C0805C225K4RACTU
C210: 100n VDDA pin21/VREF20; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C211: 100n MCU VBAT pin6; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C212: 100n reset; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0805C104K5RACTU
C213, C214: 33p C0G /0805; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 5%; Voltage Rating >=50V; MPN CC0805JRNPO9BN330
D201: GREEN; PB0 HIGH=ON; Official_LED_SMD_LED_0805_2012Metric; MPN LTST-C170GKT
D202: GREEN; 3V3_MCU_PRESENT; Official_LED_SMD_LED_0805_2012Metric; MPN LTST-C170GKT; LCSC C125090
R201: 10R VDDA filter; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710RL
R203: 10k reset pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
R204: 10k BOOT0 default LOW; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
R205: 120R HSE series; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-07120RL
R206: 1k LED current; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-071KL
R207: 1.2k PWR current; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-071K2L; LCSC C114526
TP202: BOOT0; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP204: MCU_VDDA; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP205: VCAP1; TP0p6_Inline_NoPaste; MPN TP0p6
TP206: VCAP2; TP0p6_Inline_NoPaste; MPN TP0p6
TP208: GND; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
U201: STM32H743VIT6; Official_Package_QFP_LQFP-100_14x14mm_P0.5mm; MPN STM32H743VIT6
Y201: 8.000MHz /CL20pF; Taitien_XJ_2Pad_5p5x2p0_P9p0; MPN XJHCELNANF-8M

Connections:
3V3_MCU: C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C211.1, R201.1, R203.1, R207.1, U201.6 (VBAT), U201.11 (VDD), U201.27 (VDD), U201.50 (VDD), U201.75 (VDD), U201.100 (VDD); also elsewhere on the board
/02_MCU/PWR_LED_A: D202.2 (A), R207.2
BARO_I2C2_SCL: U201.46 (PB10); also elsewhere on the board
BARO_I2C2_SDA: U201.47 (PB11); also elsewhere on the board
BMI088_ACC_CS: U201.32 (PC4); also elsewhere on the board
BMI088_GYRO_CS: U201.33 (PC5); also elsewhere on the board
BOOT0: R204.1, TP202.1, U201.94 (BOOT0)
CAN_RX: U201.81 (PD0); also elsewhere on the board
CAN_STB: U201.2 (PE3); also elsewhere on the board
CAN_TX: U201.82 (PD1); also elsewhere on the board
CORE_BAT_SELECTED: U201.1 (PE2); also elsewhere on the board
CURRENT_ADC: U201.16 (PC1); also elsewhere on the board
EXT_I2C1_SCL: U201.95 (PB8); also elsewhere on the board
EXT_I2C1_SDA: U201.96 (PB9); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, D201.1 (K), D202.1 (K), R204.2, TP208.1, U201.10 (VSS), U201.19 (VSSA), U201.26 (VSS), U201.49 (VSS), U201.74 (VSS), U201.99 (VSS); also elsewhere on the board
GPS_RX: U201.87 (PD6); also elsewhere on the board
GPS_TX: U201.86 (PD5); also elsewhere on the board
HSE_IN: C213.1, U201.12 (PH0), Y201.1
HSE_OUT: R205.1, U201.13 (PH1)
HSE_XOUT: C214.1, R205.2, Y201.2
LED_A: D201.2 (A), R206.2
MCU_VDDA: C209.1, C210.1, R201.2, TP204.1, U201.20 (VREF+), U201.21 (VDDA)
NRST: C212.1, R203.2, U201.14 (NRST); also elsewhere on the board
OUT1: U201.39 (PE9); also elsewhere on the board
OUT2: U201.41 (PE11); also elsewhere on the board
OUT3: U201.43 (PE13); also elsewhere on the board
OUT4: U201.44 (PE14); also elsewhere on the board
OUT5: U201.59 (PD12); also elsewhere on the board
OUT6: U201.60 (PD13); also elsewhere on the board
RC_RX: U201.64 (PC7); also elsewhere on the board
RC_TX: U201.63 (PC6); also elsewhere on the board
SDMMC1_CK: U201.80 (PC12); also elsewhere on the board
SDMMC1_CMD: U201.83 (PD2); also elsewhere on the board
SDMMC1_D0: U201.65 (PC8); also elsewhere on the board
SDMMC1_D1: U201.66 (PC9); also elsewhere on the board
SDMMC1_D2: U201.78 (PC10); also elsewhere on the board
SDMMC1_D3: U201.79 (PC11); also elsewhere on the board
SPI1_MISO: U201.30 (PA6); also elsewhere on the board
SPI1_MOSI: U201.31 (PA7); also elsewhere on the board
SPI1_SCK: U201.29 (PA5); also elsewhere on the board
STATUS_LED: R206.1, U201.34 (PB0)
SWCLK: U201.76 (PA14); also elsewhere on the board
SWDIO: U201.72 (PA13); also elsewhere on the board
TELEM_RX: U201.56 (PD9); also elsewhere on the board
TELEM_TX: U201.55 (PD8); also elsewhere on the board
USB_DM: U201.70 (PA11); also elsewhere on the board
USB_DP: U201.71 (PA12); also elsewhere on the board
USB_VBUS_SENSE: U201.68 (PA9); also elsewhere on the board
VBAT_ADC: U201.15 (PC0); also elsewhere on the board
VCAP1: C201.1, TP205.1 (TP_1), U201.48 (VCAP)
VCAP2: C202.1, TP206.1 (TP_1), U201.73 (VCAP)

Notes on the sheet:
STM32H743VIT6 LQFP100. Frozen B allocation; unused GPIO has explicit NC.
BOOT0 recovery: strap TP_BOOT0 to TP_3V3 with power off; then reset. No flight jumper.
02 主控与时钟 / MCU AND CLOCK
HSE 晶振 / HSE CLOCK · 8.000 MHz
复位 / RESET
启动配置 / BOOT CONFIGURATION
BOOT0 默认LOW · 恢复方式见页底说明
STM32H743 主控与去耦 / MCU CORE AND DECOUPLING
VDD 去耦 / VDD DECOUPLING
VCAP 核心稳压 / CORE REGULATOR
POWER / CONTROL
SPI / IMU / BARO
UART / I2C
SDMMC
PWM / ADC
USB / CAN / DEBUG
模拟与备份供电 / ANALOG AND BACKUP POWER
状态与电源指示 / STATUS AND PWR LED
