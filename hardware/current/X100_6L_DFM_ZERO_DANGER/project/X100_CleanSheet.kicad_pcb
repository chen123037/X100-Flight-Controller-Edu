# Repository chen123037/X100-Flight-Controller-Edu (continued)

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb (continued)

Parts:
C401: 100n clamp bypass only; Official_Capacitor_SMD_C_0805_2012Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0805C104K5RACTU
C402: 100n buffer VCC; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
J401: 124019772112A; Official_USB_C_Amphenol_124019772112A; MPN 124019772112A; LCSC C5430474
R401: 5.1k CC1 Rd; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-075K1L
R402: 5.1k CC2 Rd; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-075K1L
R403: 10k detection input; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
R404: 100k unplug LOW; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-07100KL
TP401: USB_VBUS_RAW; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP405: GND; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
U401: TPD4E1U06DBVR; SOT-23-6; MPN TPD4E1U06DBVR; LCSC C124691
U402: SN74LVC1G17DBVR; Official_Package_TO_SOT_SMD_SOT-23-5; MPN SN74LVC1G17DBVR
U403: TPD2E2U06QDBZRQ1; TI_TPD2E2U06_DBZ0003A; MPN TPD2E2U06QDBZRQ1; LCSC C488151

Connections:
3V3_MCU: C402.1, U402.5 (VCC); also elsewhere on the board
GND: C401.2, C402.2, J401.A1, J401.A12, J401.B1, J401.B12, J401.SH (SHIELD), R401.2, R402.2, R404.2, TP405.1, U401.2 (GND), U402.3 (GND), U403.3 (GND); also elsewhere on the board
USB_CC1: J401.A5, R401.1, U401.3 (D2+)
USB_CC2: J401.B5, R402.1, U401.4 (D2-)
USB_DM: J401.A7, J401.B7, U401.6 (D1-); also elsewhere on the board
USB_DP: J401.A6, J401.B6, U401.1 (D1+); also elsewhere on the board
USB_VBUS_RAW: C401.1, J401.A4, J401.A9, J401.B4, J401.B9, R403.1, TP401.1, U403.1 (IO1); also elsewhere on the board
USB_VBUS_SENSE: U402.4; also elsewhere on the board
VBUS_BUF_A: R403.2, R404.1, U402.2

Notes on the sheet:
USB DATA ONLY + VBUS SENSE. Battery/bench power required.
PA9 is software VBUS sense: configure GPIO input/session control; no raw5V on an unpowered MCU.
NO power OR, NO USB supply diode, NO USB connection to any main/sensor rail.
04 USB通信与保护 / USB INTERFACE AND PROTECTION
USB Type-C 接口 / USB TYPE-C CONNECTOR
USB 数据线 ESD / DP-DM ESD
VBUS 保护 / USB VBUS PROTECTION
CC 配置与保护 / CC CONFIGURATION AND ESD
VBUS 检测 / VBUS SENSE
USB DP / DM
VBUS / POWER / GND
