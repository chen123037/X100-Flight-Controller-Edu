# Repository chen123037/X100-Flight-Controller-Edu (continued)

## KiCad design hardware/current/X100_6L_DFM_ZERO_DANGER/project/X100_CleanSheet.kicad_pcb (continued)

Parts:
C301: 100n VDD3 loop; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C302: 100n VDDIO11 loop; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C303: 100n SPL VDD8; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
C304: 100n SPL VDDIO6; Official_Capacitor_SMD_C_0603_1608Metric; Tolerance 10%; Voltage Rating >=50V; MPN C0603C104K5RACTU
R301: 10k CS1 safe HIGH; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
R302: 10k CS2 safe HIGH; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-0710KL
R303: 4.7k internal SCL pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-074K7L
R304: 4.7k internal SDA pullup; Official_Resistor_SMD_R_0805_2012Metric; Tolerance 1%; TCR<=100ppm/C; Voltage Rating >=100V; MPN RC0805FR-074K7L
TP302: SPI1_SCK; TP0p6_Inline_NoPaste; MPN TP0p6
TP303: SPI1_MOSI; TP0p6_Inline_NoPaste; MPN TP0p6
TP304: SPI1_MISO; TP0p6_Inline_NoPaste; MPN TP0p6
TP305: BMI088_ACC_CS; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP306: BMI088_GYRO_CS; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP307: BARO_I2C2_SCL; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
TP308: BARO_I2C2_SDA; TP0p6_Inline_NoPaste; MPN PCB_TESTPAD_0P6_NO_PASTE
U301: BMI088; Bosch_BMI088_LGA16; MPN BMI088
U302: SPL06-001; Goertek_SPL06_001_LGA8; MPN SPL06-001

Connections:
3V3_SENSOR: C301.1, C302.1, C303.1, C304.1, R301.1, R302.1, R303.1, R304.1, U301.3 (VDD), U301.11 (VDDIO), U302.2 (CSB), U302.6 (VDDIO), U302.8 (VDD); also elsewhere on the board
BARO_I2C2_SCL: R303.2, TP307.1, U302.4 (SCK); also elsewhere on the board
BARO_I2C2_SDA: R304.2, TP308.1, U302.3 (SDA); also elsewhere on the board
BMI088_ACC_CS: R301.2, TP305.1, U301.14 (~CSB1); also elsewhere on the board
BMI088_GYRO_CS: R302.2, TP306.1, U301.5 (~CSB2); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, U301.2 (NC), U301.4 (GNDA), U301.6 (GNDIO), U301.7 (PS), U302.1 (GND), U302.5 (SDO_ADDR), U302.7 (GND); also elsewhere on the board
SPI1_MISO: TP304.1 (TP_1), U301.10 (SDO2), U301.15 (SDO1); also elsewhere on the board
SPI1_MOSI: TP303.1 (TP_1), U301.9 (SDI/SDA); also elsewhere on the board
SPI1_SCK: TP302.1 (TP_1), U301.8 (SCK/SCL); also elsewhere on the board

Notes on the sheet:
Single BMI088 SPI1 and single SPL06-001 I2C2. No compass/second IMU.
SPL: CSB2=VDDIO; SDO5=GND => I2C0x76. BMI: PS7=GND; NC2=GND.
SPI initialization must toggle accel CS and discard dummy read. Sensor-off GPIO must not drive.
03 传感器 / SENSORS
BMI088 惯性测量 / BMI088 IMU · SPI1
SPL06-001 气压计 / BAROMETER · I2C2
传感器接口与测点 / SENSOR INTERFACES AND TEST
POWER / GND
SPI1 / IMU
I2C2 / BARO
